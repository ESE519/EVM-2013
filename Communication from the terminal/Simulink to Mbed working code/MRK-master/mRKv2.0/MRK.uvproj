# Keil uVision project MRK.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MRK
  AfterMake: fromelf --bin -o E:\@L.bin !L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: TARGET_LPC1768
  c include: .\mbed;.\mbed\LPC1768
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\mbed\LPC1768\LPC1768.sct
  link misc: .\mbed\LPC1768\startup_LPC17xx.o
.\mbed\LPC1768\system_LPC17xx.o
.\mbed\LPC1768\stackheap.o
.\mbed\LPC1768\core_cm3.o
.\mbed\LPC1768\cmsis_nvic.o
.\mbed\LPC1768\capi.ar
.\mbed\LPC1768\mbed.ar
  group src
    ./mrk_uvision_lpc1768/mrk/NanoRk/src/drivers/include/: nrk_driver_list.h
    ./mrk_uvision_lpc1768/mrk/NanoRk/src/kernel/hal/LPC1768/: nrk_cpu.cpp nrk_status.cpp nrk_timer.cpp nrk_watchdog.cpp
    ./mrk_uvision_lpc1768/mrk/NanoRk/src/kernel/source/: nrk.cpp nrk_error.cpp nrk_events.cpp nrk_idle_task.cpp nrk_reserve.cpp nrk_scheduler.cpp nrk_stack_check.cpp nrk_stats.cpp nrk_task.cpp nrk_time.cpp nrk_driver.cpp
    ./mrk_uvision_lpc1768/mrk/NanoRk/src/platform/mbed/source/: hal_wait.cpp ulib.cpp
    ./mrk_uvision_lpc1768/mrk/: my_asm.s
    ./mrk_uvision_lpc1768/mrk/NanoRk/src/drivers/platform/mbed/: adc_driver.cpp ff_basic_sensor.cpp
    ./mrk_uvision_lpc1768/mrk/NanoRk/src/net/bmac/: bmac.cpp
    ./mrk_uvision_lpc1768/mrk/NanoRk/src/radio/mrf24j40/source/: basic_rf.cpp MRF24J40.cpp
    ./mrk_uvision_lpc1768/mrk/NanoRk/Projects/Simulink/: MW_target_hardware_resources.h rtwtypes.h simulinkmodeltoblinkLed.h simulinkmodeltoblinkLed_private.h simulinkmodeltoblinkLed_types.h main.cpp simulinkmodeltoblinkLed.cpp simulinkmodeltoblinkLed_data.cpp
    ./: Servo.cpp Servo.h
target mbed NXP LPC2368 (ARM-ADS)
  device: LPC2368 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  AfterMake: fromelf --bin -o @L.bin  !L
  c flags: Optim=3
  c define: TARGET_LPC2368
  c include: .\mbed;.\mbed\LPC2368
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  scatter file: .\mbed\LPC2368\LPC2368.sct
  link misc: .\mbed\LPC2368\vector_realmonitor.o
.\mbed\LPC2368\vector_functions.o
.\mbed\LPC2368\system_LPC23xx.o
.\mbed\LPC2368\stackheap.o
.\mbed\LPC2368\mbed.ar
.\mbed\LPC2368\core_arm7.o
.\mbed\LPC2368\cmsis_nvic.o
.\mbed\LPC2368\capi.ar
.\mbed\LPC2368\vector_table.o
